# Keil uVision project Project.uvprojx, settings and files
target F407_Target (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Target407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: .\Library\CMSIS\Device\ST\STM32F4xx\Include;.\Library\CMSIS\Include;.\Library\STM32F4xx_StdPeriph_Driver\inc;.\User;.\User\arm;.\User\calibration;.\User\rs485;.\User\tcp;.\User\ui;.\User\matrix;.\User\app;.\System;.\Hardware;.\Hardware\lcd;.\Hardware\font;.\Hardware\touch;.\Hardware\flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: stm32f407.sct
  group Start
    ./Start/: startup_stm32f407xx.s
  group System
    ./System/: system_stm32f4xx.c stm32f4xx_it.c delay.c delay.h sys.c sys.h global_config.h stm32f4xx_it.h stm32f4xx_conf.h
  group Library
    ./Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Hardware
    ./Hardware/: bsp_led.c bsp_led.h bsp_conveyor.c bsp_conveyor.h bsp_key.c bsp_key.h bsp_exti.c bsp_exti.h bsp_uart.c bsp_uart.h bsp_uart2.c bsp_uart2.h bsp_uart3.c bsp_uart3.h bsp_buzzer.c bsp_buzzer.h
    ./Hardware/touch/: bsp_i2c_touch.c bsp_i2c_touch.h gt9xx.c gt9xx.h gui_drv_cfg.h
    ./Hardware/lcd/: bsp_nt35510_lcd.c bsp_nt35510_lcd.h
    ./Hardware/font/: fonts.c fonts.h
    ./Hardware/flash/: bsp_spi_flash.c bsp_spi_flash.h
  group User
    ./User/: main.c
    ./User/ui/: app_display.c app_display.h
    ./User/tcp/: app_protocol.c app_protocol.h
    ./User/arm/: app_kinematics.c app_kinematics.h app_motor.c app_motor.h app_motion_abort.c app_motion_abort.h app_arm.c app_arm.h
    ./User/matrix/: app_matrix.c app_matrix.h app_matrix_raw_validator.c app_matrix_raw_validator.h app_matrix_test.c app_matrix_test.h app_matrix_modbus.c app_matrix_modbus.h
    ./User/app/: app_conveyor.c app_conveyor.h app_sort.c app_sort.h
    ./User/rs485/: modbus_crc.c modbus_crc.h modbus_master.c modbus_master.h app_485_devices.c app_485_devices.h app_alarm_light.c app_alarm_light.h
